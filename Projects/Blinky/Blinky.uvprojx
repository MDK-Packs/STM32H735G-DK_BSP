# Keil uVision project Blinky.uvprojx, settings and files
target STM32H735G-DK (6160000::V6.16::ARMCLANG)
  device: STM32H735IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\stm32h735.sct
  link misc: --any_placement=first_fit
  group App
    ./: Blinky.c
  group :STM32CubeMX:Common Sources
    ./STM32CubeMX/STCubeGenerated/Src/: main.c stm32h7xx_it.c
    ./STM32CubeMX/STCubeGenerated/Inc/: stm32h7xx_it.h
  group STM32CubeMX
    ./STM32CubeMX/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.5.1, Board Support:Components:MX25LM51245G 2.0.2, Board Support:Components:S70KL1281 1.0.0, Board Support:Drivers:BUS 1.2.0, Board Support:Drivers:Basic I/O 1.2.0, Board Support:Drivers:OSPI 1.2.0, CMSIS Driver:VIO:Board 1.1.0, Device:STM32Cube HAL:Common 1.9.0, Device:STM32Cube HAL:Cortex 1.9.0, Device:STM32Cube HAL:DMA 1.9.0, Device:STM32Cube HAL:DMA2D 1.9.0, Device:STM32Cube HAL:EXTI 1.9.0, Device:STM32Cube HAL:GPIO 1.9.0, Device:STM32Cube HAL:I2C 1.9.0, Device:STM32Cube HAL:LTDC 1.9.0, Device:STM32Cube HAL:MDMA 1.9.0, Device:STM32Cube HAL:OSPI 1.9.0, Device:STM32Cube HAL:PWR 1.9.0, Device:STM32Cube HAL:RCC 1.9.0, Device:STM32Cube HAL:UART 1.9.0, Device:Startup 1.9.0
